#UBOOT_SRC = "git://github.com/btclark1/uboot-imx.git;protocol=git"

UBOOT_SRC = "git://${BSPDIR}/local_repos/uboot-imx;protocol=file"

SRCBRANCH = "imx_v2020.04_5.4.24_2.1.0_var02"

#SRCREV = "3f20447a552b8cd74fcc658fac4402e24f6db60b"
SRCREV = "${AUTOREV}"

